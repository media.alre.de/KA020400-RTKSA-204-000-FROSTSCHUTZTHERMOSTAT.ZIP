Properties of the parts of a building model (IFC4)

# File
Description: Frostschutzthermostat, 1,8 m, IP40, Hysterese 1,5 K, STW, Inneneinstellung, Außenrückstellung, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: KA020400, Frostschutzthermostat, 1,8 m, IP40, Hysterese 1,5 K, STW, Inneneinstellung, Außenrückstellung
In: Raum
Description: Die Frostschutzregler RTKSA wurden speziell zur luft- oder wasserseitigen Frostschutzsicherung von Warmwasser-Heizregistern und Wärmetauschern in Lüftungs-, Heizungs- oder Klimaanlagen entwickelt. Bei einem Fühlerbruch wird der Kontakt 1–2 dauerhaft geöffnet und der Kontakt 1–4 dauerhaft geschlossen. Hinweis: Montageklammern, Tauchhülsen und Schutzwendel gehören nicht zum Lieferumfang und müssen separat bestellt werden. Luftseitige Anwendung: Für Temperaturmessung nicht aggressiver Gase im Kanal können die Schutzwendeln SWK-2-xxx verwendet werden. Wasserseitige Anwendung: Für Temperaturmessung in nicht aggressiven Fluiden können die Tauchhülsen THK-2-xxx sowie in aggressiven Fluiden die Tauchhülsen NTHK-2-xxx verwendet werden.; Classification: EC011174 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: KA020400; ModelLabel: RTKSA-204.000; GlobalTradeItemNumber: 4050528074874; ProductURL: https://alre.de/produkt_KA020400
Pset_Specification - NominalLength: 0.1468 m; NominalWidth: 0.0576 m; NominalDepth: 0.053 m; NetWeight: 0.254
Pset_ALRE_ETIM_Properties - Breite: 57.6; Höhe: 146.8; Tiefe: 53; Messbereich: 10; Explosionsgeschützt: no; Schutzart (IP): IP40; Max. Mediumtemperatur (Dauerbetrieb): 120; Länge Kapillar: 1.8; Max. Spannung der Kontakte: 230; Kontaktverriegelung: yes; Max. Kontaktbelastung: 16; Schaltdifferenz einstellbar: no; ETIM-Klasse: EC011174; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-KA020400.pdf
